# Keil uVision project Entrance_V5.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Entrance_V5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\USER_V5;..\UART;..\Source\include;..\Source;..\Source\portable\RVDS\ARM_CM3;..\FWlib\inc;..\CMSIS;..\LED;..\UART;..\Keyscan;..\RC522;..\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER_V5
    ./: main.c stm32f10x_it.c user_task.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group UART
    ../UART/: usart1.c
  group FreeRTOS
    ../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Source/portable/MemMang/: heap_4.c
    ../Source/portable/RVDS/ARM_CM3/: port.c
  group LED
    ../LED/: led.c
  group Keyscan
    ../Keyscan/: keyscan.c
  group RC522
    ../RC522/: rc522.c rc522_spi_driver.c rc522_handle.c
  group OLED
    ../OLED/: oled.c
